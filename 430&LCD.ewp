# IAR project 430&LCD.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: C:\Users\Bruce\Desktop\毕业设计\13898402TS8900-M149\TS8900-M149代码\1\Cry1602液晶显示\C1
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: main.c
